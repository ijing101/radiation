# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F130F8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.7.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\GD32F1x0_standard_peripheral\Include;.\Hardware;.\Start;.\SYSTEM;.\USER
  memory RVCT4: ROM 0x8005000 size 0xa800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./USER/: gd32f1x0_it.c main.c system_gd32f1x0.c
  group Hardware
    ./Hardware/: eeprom.c Hx711.c iap_trigger.c modbus.c modbus_crc.c rs485.c timer.c wdg.c
  group SYSTEM
    ./SYSTEM/: delay.c
  group CMSIS
    ./GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Start
    ./Start/: startup_gd32f1x0.s
