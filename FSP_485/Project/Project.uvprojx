# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F130F8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.7.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\Libraries\CMSIS\GD\GD32F1x0\Include;..\Libraries\CMSIS;..\Libraries\GD32F1x0_standard_peripheral\Include;..\Libraries\App;..\User;..\Libraries\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.h
    ../Libraries/CMSIS/GD/GD32F1x0/Include/: system_gd32f1x0.h gd32f1x0.h
    ../Libraries/App/: gd32f1x0_libopt.h gd32f1x0_it.h
  group StdPeriphLib
    ../Libraries/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group App
    ../Libraries/App/: Hx711.h main.h systick.h Usart.h
  group User
    ../User/: systick.c gd32f1x0_it.c main.c Hx711.c Usart.c IIC.c IIC.h TIMER.c
    ../Libraries/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Startup
    ../Libraries/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
